# Repository baoshi/SmartAPS

## KiCad design hw/SmartAPS.kicad_pcb

Parts:
BZ1: BUZZER; Buzzer_9.2x4.8x4P
C1, C9, C11: 22u; CP_POSCAP_TQC-D2; Rating 25V; Mfg P/N 25TQC22MV
C2, C3, C4: 1u; C_0805; Rating 50V; Mfg P/N CL21B105KBFNNNE; JLC P/N C28323
C5, C12, C16, C19: 22u; C_1210; Rating 25V; Mfg P/N GRM32ER71E226KA88L
C6: 100p; C_0603
C7: 47u; C_1206; Rating 10V; Mfg P/N LMK316BJ476ML-T
C8, C10, C14, C18, C22, C25, C26: 0.1u; C_0603; Mfg P/N CL10B104KB8NNNC; JLC P/N C1591
C13: 100u; CP_6.3x5.8; Rating 25V; Mfg P/N EEEFT1E101AP; JLC P/N C178590
C15: 1n; C_0603
C17: 220u; CP_6.3x7.7; Rating 25V; Mfg P/N EEEFTE221XAP; JLC P/N C190724
C20, C21: 0.1u; C_0603
C23, C24: 100u; C_1206; Mfg P/N CL31A107MQHNNNE; JLC P/N C15008
D1: SMBJ16A; D_SMB
D2: PWR; D_LED_0603
D3, D5, D7: 15V; D_SOD-123; Mfg P/N MMSZ4702-E3-08; JLC P/N C241967
D4, D6: 1N5822; D_SMA
D8: 1N4001; D_SMA
DISP1: OLED_LM320Y-256064; LM320Y-256064-ASM-LP
FB1: 600R; L_0805; Mfg P/N CBW201209U601T; JLC P/N C21286
L1: 22uH; L_Panasonic_PCC-M1054M; Mfg P/N ETQP5M220YFC; JLC P/N C409633
M1, M2, M3: Mechanical-NC; Hole-Mech_M2.5
M4: Mechanical; Slot_5x0.5
P1: 12V IN; SCREWTERM-2_3.5P
P2: GND; SCREWTERM-2_3.5P
P3: OUT1; JST_B4B-XH-AM
P4: OUT2; JST_B4B-XH-AM
P5: USB_C_Receptacle_16P; HRO_TYPE-C-31-M-12
P6: JESP32-DBG; BHDR-THT-Vert-50mil_02x05
P7: Grove I2C; JST_S4B-PH-SM4-TB
Q1, Q3, Q5, Q8: MMBT5551; SOT-23-3
Q2, Q4, Q6: DMP3013SFV; Diodes_DMP3013SFV
Q7: TEMT6000X01; Vishay_TEMT6000X01
R1, R2: 22K; R_0603
R3, R7: 0R01; R_1206; Mfg P/N LR1206-21R010F4; JLC P/N C154635
R4, R6, R8, R10, R12, R16, R20, R23, R24: 10K; R_0603
R5, R9, R11: 51K; R_0603
R13: 2R; R_0603
R14: 3.3K; R_0603
R15: 0R025; R_1206; Mfg P/N LR1206-21R025F4; JLC P/N C154642
R17: 100K; R_0603
R18: 1K; R_0603
R19: 330; R_0603
R21, R22: 2.2K; R_0603
S1: ENTER; SW-PUSH-SMT_6x6x4.3H
S2: CH1; SW-PUSH-SMT_6x6x4.3H
S3: CH2; SW-PUSH-SMT_6x6x4.3H
S4: RESET; SW-PUSH_4x3x2H
TP1: 12V; TP_Loop
TP2: GND; TP_Loop
TP3: GND; TE_RCT0805
TP4: 3V3; TE_RCT0805
TP5: VUSB; TE_RCT0805
U1: MCP1703T-3302E/MB; SOT-89-3
U2: MUN12AD01-SH
U3, U4, U6: INA226; VSSOP-10_3x3x0.5P
U5: IP6510; SOIC-8-1EP_4.9x3.9x1.27P
U7: ESP32-WROOM-32U
U8: STM1001RWX6F; SOT-23-3; JLC P/N C115151

Connections:
3V3: BZ1.1, C6.1, C7.1, C23.1, C24.1, C25.1, D8.K, DISP1.2 (VBAT), P6.1, Q7.C, R20.1, R23.1, R24.1, TP4.1, U2.4 (VOUT), U7.2 (3V3), U8.2 (VCC)
12V: C1.1, C2.1, C5.1, D1.K, D7.K, FB1.2, P1.1, P1.2, Q6.S, R1.2, R3.2, R7.2, R11.1, TP1.1, U2.7 (EN), U2.8 (VIN), U3.10 (VIN+), U4.10 (VIN+)
/ALT1: R4.1, U3.3 (ALERT), U7.12 (IO27)
/ALT2: R8.1, U4.3 (ALERT), U7.9 (IO33)
/ALT_USB: R16.1, U6.3 (ALERT), U7.26 (IO4)
/BUZ: R18.1, U7.10 (IO25)
/CC1: P5.A5 (CC1), U5.7 (CC1)
/CC2: P5.B5 (CC2), U5.8 (CC2)
/DM: P5.A7 (D-), P5.B7 (D-), U5.5 (DM)
/DP: P5.A6 (D+), P5.B6 (D+), U5.6 (DP)
/EN: C26.1, P6.10, R20.2, S4.1, U7.3 (EN), U8.1 (~RESET)
/IO0: P6.3, S1.1, U7.25 (IO0)
/LIGHT: C22.1, Q7.E, R17.1, U7.4 (SVP/IO36)
/MOSI: DISP1.5 (DB1/SDIN), U7.37 (IO23)
/OLED_DC: DISP1.14 (DC), U7.31 (IO19)
/OLED_RES: DISP1.15 (~RESET), U7.29 (IO5)
/OUT1: C9.1, D4.K, P3.1, P3.2, Q2.D
/OUT2: C11.1, D6.K, P4.1, P4.2, Q4.D
/PWR1: Q1.1 (B), U7.11 (IO26)
/PWR2: Q3.1 (B), U7.8 (IO32)
/PWR_USB: Q5.1 (B), U7.27 (IO16)
/RX: P6.7, U7.34 (RXD0/IO3)
/SCL: P7.1, R21.2, U3.5 (SCL), U4.5 (SCL), U6.5 (SCL), U7.36 (IO22)
/SCLK: DISP1.4 (DB0/SCLK), U7.30 (IO18)
/SDA: P7.2, R22.2, U3.1 (A1), U3.2 (A0), U3.4 (SDA), U4.4 (SDA), U6.4 (SDA), U7.33 (IO21)
/SW2: C20.2, R23.2, S2.1, U7.6 (IO34)
/SW3: C21.2, R24.2, S3.1, U7.7 (IO35)
/TCK: P6.4, U7.16 (IO13)
/TDI: P6.8, U7.14 (IO12)
/TDO: P6.6, U7.23 (IO15)
/TMS: P6.2, U7.13 (IO14)
/TX: P6.5, U7.35 (TXD0/IO1)
/~OLED_CS: DISP1.16 (~CS), U7.28 (IO17)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.1, C21.1, C22.2, C23.2, C24.2, C25.2, C26.2, D1.A, D2.K, D4.A, D6.A, DISP1.1 (VSS), DISP1.7 (DB3), DISP1.8 (DB4), DISP1.9 (DB5), DISP1.10 (DB6), DISP1.11 (DB7), DISP1.12 (~RD), DISP1.13 (~WR), M4.1, P2.1, P2.2, P3.3, P3.4, P4.3, P4.4, P5.A1 (GND), P5.A12 (GND), P5.B1 (GND), P5.B12 (GND), P5.S1 (SHIELD), P6.9, P7.4, Q8.2 (E), R2.2, R6.2, R10.2, R12.2, R14.2, R17.2, S1.2, S2.2, S3.2, S4.2, TP2.1, TP3.1, U1.1 (GND), U2.5 (GND), U2.9 (GND), U3.7 (GND), U4.1 (A1), U4.7 (GND), U5.9 (GND), U6.7 (GND), U7.1 (GND), U7.15 (GND), U7.38 (GND), U7.39 (GND), U8.3 (GND)
unnamed: BZ1.2, D8.A, R19.1
unnamed: C3.1, FB1.1, U1.2 (VI)
unnamed: C6.2, R2.1, U2.2 (FB)
unnamed: C12.1, C13.1, Q6.D, U5.2 (VIN)
unnamed: C14.1, L1.1, R13.1, U5.3 (SW)
unnamed: C14.2, U5.4 (BST)
unnamed: C15.1, R13.2
unnamed: C16.1, C17.1, L1.2, R14.1, R15.2, U5.1 (VOUT), U6.10 (VIN+)
unnamed: C19.1, P5.A4 (VBUS), P5.A9 (VBUS), P5.B4 (VBUS), P5.B9 (VBUS), R15.1, TP5.1, U6.8 (VBUS), U6.9 (VIN-)
unnamed: D2.A, R1.1
unnamed: D3.A, Q1.3 (C), Q2.G, R5.2
unnamed: D3.K, Q2.S, R3.1, R5.1, U3.8 (VBUS), U3.9 (VIN-)
unnamed: D5.A, Q3.3 (C), Q4.G, R9.2
unnamed: D5.K, Q4.S, R7.1, R9.1, U4.8 (VBUS), U4.9 (VIN-)
unnamed: D7.A, Q5.3 (C), Q6.G, R11.2
unnamed: Q1.2 (E), R6.1
unnamed: Q3.2 (E), R10.1
unnamed: Q5.2 (E), R12.1
unnamed: Q8.1 (B), R18.2
unnamed: Q8.3 (C), R19.2
VDDA: C4.1, C8.1, C10.1, C18.1, P7.3, R4.2, R8.2, R16.2, R21.1, R22.1, U1.3 (VO), U3.6 (VS+), U4.2 (A0), U4.6 (VS+), U6.1 (A1), U6.2 (A0), U6.6 (VS+)

Notes on the sheet:
AD = 0x4A WR = 0x94 RD = 0x95
AD = 0x45 WR = 0x8A RD = 0x8B
AD = 0x41 WR = 0x82 RD = 0x83

Board: 2 copper layers, 130.0 x 60.0 mm, 98 parts (12 on the bottom side), 55 nets.

## Commit log

2020-04-30 Solve INA226/SHT20 address clash
2020-05-09 Remove i2c dependency
2020-05-09 Better compliance
2020-05-09 Add in Xiaomi BLE integration, adjust partition
2020-05-10 Bug fixes, Remove SHT20
2020-05-10 No need gerber
2020-05-13 Sample buffer testing works
2020-05-14 i2c not stable. stage first before use bitbang
2020-05-17 Skeleton of new architecture
2020-05-17 framework for shell tested
2020-05-19 Overview Shell working
2020-05-19 Auto-off for overview shell
2020-05-20 Screensaver shell added
2020-05-20 Draw UI immediately after enter overview shell
2020-05-21 fix cannot go into screen saver when button pressed
2020-05-21 bug fixes and start implementation of detail shell
2020-05-22 Change TEMT6000 output resistor to 100K
2020-05-25 adapt to new hardware
2020-05-25 WIP current waveform
2020-05-27 Everything working
2020-06-01 Reduce periodical V/A report to 1 minutes. No crash yet.
2020-06-01 Move firmware to fw folder
2020-06-01 Move hardware design to hw folder
2020-06-15 fix typo
2020-06-15 reduce low light threshold
2020-06-15 Remove BLE support. BLE causes many WiFi and update problem because of RAM limit
2020-10-11 Cleanup
2021-03-28 Follow header name change
2021-03-28 Follow pin header name change
